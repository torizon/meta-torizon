RDEPENDS:packagegroup-core-full-cmdline-utils:remove = "\
    bc \
    coreutils \
    cpio \
    findutils \
    gawk \
    grep \
    mc \
    mc-fish \
    mc-helpers \
    mc-helpers-perl \
    mc-shell \
    tar \
"

RDEPENDS:packagegroup-core-full-cmdline-multiuser:remove = "\
    gzip \
"
