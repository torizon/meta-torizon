# nft's interactive CLI: libedit instead of readline (GPL-3.0-or-later)
PACKAGECONFIG:remove = "readline"
PACKAGECONFIG:append = " editline"
